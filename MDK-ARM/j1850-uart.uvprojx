# Keil uVision project j1850-uart.uvprojx, settings and files
target j1850-uart (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: j1850-uart
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;                       C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Drivers/STM32F1xx_HAL_Driver/Inc;                       C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                       C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                       C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                       C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Drivers/CMSIS/Device/ST/STM32F1xx/Include;                       C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f1xx_it.c gpio.c usbd_desc.c tim.c usbd_cdc_if.c usbd_conf.c stm32f1xx_hal_msp.c main.c usb_device.c spi.c dma.c usart.c
  group Drivers/CMSIS
    C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pcd.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_ll_usb.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Middlewares/USB_Device_Library
    C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    C:/Users/hunter/STM32Cube/Repository/STM32Cube_FW_F1_V1.4.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 4.1.0
